inherit externalsrc
EXTERNALSRC = "/home/jourdes/w/src/gpio-toggle"
EXTERNALSRC_BUILD = "/home/jourdes/w/src/gpio-toggle"

# initial_rev .: be58dc8217a58a112d578682a01f1fc1c30fe080
